# IAR project Demo_appserial.ewp, settings and files
configuration STK3200_SI4460_Meter_S1 (ARM)
  General.OGChipSelectEditMenu: EFM32ZG222F32 SiliconLaboratories EFM32ZG222F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STK3200
  ICCARM.PreInclude: ..\..\..\src\configs\Meter_S1.h
  ICCARM.CCIncludePath2: ..\..\..\src\hal\mcu\EFM32LIB\Device\EFM32ZG\Include; ..\..\..\src\hal\mcu\EFM32LIB\emlib\inc; ..\..\..\src\hal\mcu\EFM32LIB\usb\inc; ..\..\..\src\hal\mcu\EFM32LIB\CMSIS\Include; ..\..\..\src\configs\boards; ..\..\..\src\configs\prj_config\app\serial; ..\..\..\inc; ..\..\..\src; ..\..\..\src\target; ..\..\..\src\stack; ..\..\..\src\hal; ..\..\..\src\hal\mcu\config; ..\..\..\src\stack\src\apps\serial\apl; ..\..\..\src\app\serial; ..\..\..\src\hal\rf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: appserial.bin
  ILINK.IlinkOutputFile: appserial.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../src/stack/src/apps/serial/apl/: app_serial.c
  group HAL
    ../../../src/target/: sf_hal.c sf_hal_aes.c sf_hal_gpio.c sf_hal_leuart.c sf_hal_mcu.c sf_hal_mem.c sf_hal_rf.c sf_hal_spi.c sf_hal_tmr.c
  group lib/RF/SI4460_CortexM0+_Meter_S1
    ../../../libs/rf/SI4460/CortexM0+/Meter_S1/: librf.a
  group lib/Stack/CortexM0+_Meter_S1_Serial
    ../../../libs/stack/CortexM0+/Meter_S1/Serial/: libstack.a
  group MCU/EFM32LIB
    ../../../src/hal/mcu/EFM32LIB/emlib/src/: em_aes.c em_cmu.c em_dbg.c em_emu.c em_gpio.c em_int.c em_leuart.c em_msc.c em_system.c em_timer.c em_usart.c
  group MCU/EFM32LIB/efm32zg
    ../../../src/hal/mcu/EFM32LIB/Device/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../src/hal/mcu/EFM32LIB/Device/EFM32ZG/Source/: system_efm32zg.c
