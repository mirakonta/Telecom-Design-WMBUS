# IAR project Demo_appserial.ewp, settings and files
configuration STK3200_SI4460_Meter_S1 (ARM)
  General.OGChipSelectEditMenu: EFM32G210F128 SiliconLaboratories EFM32G210F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TD1208
  ICCARM.PreInclude: ..\..\..\src\configs\Collector_T2.h
  ICCARM.CCIncludePath2: ..\..\..\src\hal\mcu\EFM32LIB\Device\EFM32G\Include; ..\..\..\src\hal\mcu\EFM32LIB\emlib\inc; ..\..\..\src\hal\mcu\EFM32LIB\usb\inc; ..\..\..\src\hal\mcu\EFM32LIB\CMSIS\Include; ..\..\..\src\configs\boards; ..\..\..\src\configs\prj_config\app\serial; ..\..\..\inc; ..\..\..\src; ..\..\..\src\target; ..\..\..\src\stack; ..\..\..\src\hal; ..\..\..\src\hal\mcu\config; ..\..\..\src\stack\src\apps\serial\apl; ..\..\..\src\app\serial; ..\..\..\src\hal\rf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: appserial.bin
  ILINK.IlinkOutputFile: appserial.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../src/stack/src/apps/serial/apl/: app_serial.c
  group HAL
    ../../../src/target/: sf_hal.c sf_hal_aes.c sf_hal_gpio.c sf_hal_leuart.c sf_hal_mcu.c sf_hal_mem.c sf_hal_rf.c sf_hal_spi.c sf_hal_tmr.c
  group lib/RF/SI4461_CortexM3_Collector_T2
    ../../../libs/rf/SI4461/CortexM3/Collector_T2/: librf.a
  group lib/Stack/CortexM3_Collector_T2_Serial
    ../../../libs/stack/CortexM3/Collector_T2/Serial/: libstack.a
  group MCU/EFM32LIB
    ../../../src/hal/mcu/EFM32LIB/emlib/src/: em_aes.c em_cmu.c em_dbg.c em_emu.c em_gpio.c em_int.c em_leuart.c em_msc.c em_system.c em_timer.c em_usart.c
  group MCU/EFM32LIB/efm32zg
    ../../../src/hal/mcu/EFM32LIB/Device/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../src/hal/mcu/EFM32LIB/Device/EFM32ZG/Source/: system_efm32zg.c
