# IAR project Demo_appserial.ewp, settings and files
configuration SLWSTK6200A_Meter_S2 (ARM)
  General.OGChipSelectEditMenu: EFM32LG330F256 SiliconLaboratories EFM32LG330F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SLWSTK6200A
  ICCARM.PreInclude: ..\..\..\src\configs\Meter_S2.h
  ICCARM.CCIncludePath2: ..\..\..\src\hal\mcu\EFM32LIB\Device\EZR32LG\Include; ..\..\..\src\hal\mcu\EFM32LIB\emlib\inc; ..\..\..\src\hal\mcu\EFM32LIB\usb\inc; ..\..\..\src\hal\mcu\EFM32LIB\CMSIS\Include; ..\..\..\src\configs\boards; ..\..\..\src\configs\prj_config\app\serial; ..\..\..\inc; ..\..\..\src; ..\..\..\src\target; ..\..\..\src\stack; ..\..\..\src\hal; ..\..\..\src\hal\mcu\config; ..\..\..\src\stack\src\apps\serial\apl; ..\..\..\src\app\serial; ..\..\..\src\hal\rf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: appserial.bin
  ILINK.IlinkOutputFile: appserial.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SLWSTK6200A_Collector_S2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SLWSTK6220A
  ICCARM.PreInclude: ..\..\..\src\configs\Collector_S2.h
  ICCARM.CCIncludePath2: ..\..\..\src\hal\mcu\EFM32LIB\Device\EZR32WG\Include; ..\..\..\src\hal\mcu\EFM32LIB\emlib\inc; ..\..\..\src\hal\mcu\EFM32LIB\usb\inc; ..\..\..\src\hal\mcu\EFM32LIB\CMSIS\Include; ..\..\..\src\configs\boards; ..\..\..\src\configs\prj_config\app\serial; ..\..\..\inc; ..\..\..\src; ..\..\..\src\target; ..\..\..\src\stack; ..\..\..\src\hal; ..\..\..\src\hal\mcu\config; ..\..\..\src\stack\src\apps\serial\apl; ..\..\..\src\app\serial; ..\..\..\src\hal\rf
  group Application
    ../../../src/stack/src/apps/serial/apl/: app_serial.c
  group HAL
    ../../../src/target/: sf_hal.c sf_hal_aes.c sf_hal_gpio.c sf_hal_mcu.c sf_hal_mem.c sf_hal_rf.c sf_hal_spi.c sf_hal_tmr.c sf_hal_usartUsb.c
  group lib/RF/SI4460C_CortexM3_Collector_S2
    ../../../libs/rf/SI4460C/CortexM3/Collector_S2/: librf.a
  group lib/RF/SI4460C_CortexM3_Meter_S2
    ../../../libs/rf/SI4460C/CortexM3/Meter_S2/: librf.a
  group lib/Stack/CortexM3_Collector_S2_Serial
    ../../../libs/stack/CortexM3/Collector_S2/Serial/: libstack.a
  group lib/Stack/CortexM3_Meter_S2_Serial
    ../../../libs/stack/CortexM3/Meter_S2/Serial/: libstack.a
  group MCU
    ../../../src/hal/mcu/config/: descriptors.c
  group MCU/EFM32LIB
    ../../../src/hal/mcu/EFM32LIB/emlib/src/: em_aes.c em_cmu.c em_dbg.c em_emu.c em_gpio.c em_int.c em_leuart.c em_msc.c em_system.c em_timer.c em_usart.c
  group MCU/EFM32LIB/ezr32lg
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32LG/Source/IAR/: startup_ezr32lg.s
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32LG/Source/: system_ezr32lg.c
  group MCU/EFM32LIB/ezr32wg
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32WG/Source/IAR/: startup_ezr32wg.s
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32WG/Source/: system_ezr32wg.c
  group MCU/EFM32LIB/usb
    ../../../src/hal/mcu/EFM32LIB/usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
