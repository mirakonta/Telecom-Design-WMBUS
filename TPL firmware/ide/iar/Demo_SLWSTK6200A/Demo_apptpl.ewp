# IAR project Demo_apptpl.ewp, settings and files
configuration SLWSTK6200A_Meter_S2 (ARM)
  General.OGChipSelectEditMenu: EFM32LG330F256 SiliconLaboratories EFM32LG330F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SLWSTK6200A
  ICCARM.PreInclude: ..\..\..\src\configs\Meter_S2.h
  ICCARM.CCIncludePath2: ..\..\..\src\hal\mcu\EFM32LIB\Device\EZR32LG\Include; ..\..\..\src\hal\mcu\EFM32LIB\emlib\inc; ..\..\..\src\hal\mcu\EFM32LIB\usb\inc; ..\..\..\src\hal\mcu\EFM32LIB\CMSIS\Include; ..\..\..\src\configs\boards; ..\..\..\src\configs\prj_config\app\apl; ..\..\..\inc; ..\..\..\src; ..\..\..\src\target; ..\..\..\src\stack; ..\..\..\src\hal; ..\..\..\src\hal\mcu\config; ..\..\..\src\stack\src\apps\demos\apl; ..\..\..\src\hal\rf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: appapl.bin
  ILINK.IlinkOutputFile: appapl.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SLWSTK6200A_Collector_S2 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32LG360F256 SiliconLaboratories EFM32LG360F256
  ICCARM.CCDefines: SLWSTK6220A
  ICCARM.PreInclude: ..\..\..\src\configs\Collector_S2.h
  ICCARM.CCIncludePath2: ..\..\..\src\hal\mcu\EFM32LIB\Device\EZR32WG\Include; ..\..\..\src\hal\mcu\EFM32LIB\emlib\inc; ..\..\..\src\hal\mcu\EFM32LIB\usb\inc; ..\..\..\src\hal\mcu\EFM32LIB\CMSIS\Include; ..\..\..\src\configs\boards; ..\..\..\src\configs\prj_config\app\apl; ..\..\..\inc; ..\..\..\src; ..\..\..\src\target; ..\..\..\src\stack; ..\..\..\src\hal; ..\..\..\src\hal\mcu\config; ..\..\..\src\stack\src\apps\demos\apl; ..\..\..\src\hal\rf
  group Application
    ../../../src/stack/src/apps/demos/tpl/: main_collector.c main_meter.c
  group HAL
    ../../../src/target/: sf_hal.c sf_hal_aes.c sf_hal_gpio.c sf_hal_mcu.c sf_hal_mem.c sf_hal_rf.c sf_hal_spi.c sf_hal_tmr.c
  group lib/RF/SI4460C_CortexM3_Collector_S2
    ../../../libs/rf/SI4460C/CortexM3/Collector_S2/: librf.a
  group lib/RF/SI4460C_CortexM3_Meter_S2
    ../../../libs/rf/SI4460C/CortexM3/Meter_S2/: librf.a
  group lib/Stack/CortexM3_Collector_S2_Tpl
    ../../../libs/stack/CortexM3/Collector_S2/Tpl/: libstack.a
  group lib/Stack/CortexM3_Meter_S2_Tpl
    ../../../libs/stack/CortexM3/Meter_S2/Tpl/: libstack.a
  group MCU
    ../../../src/hal/mcu/config/: descriptors.c
  group MCU/EFM32LIB
    ../../../src/hal/mcu/EFM32LIB/emlib/src/: em_aes.c em_cmu.c em_dbg.c em_emu.c em_gpio.c em_int.c em_msc.c em_system.c em_timer.c em_usart.c
  group MCU/EFM32LIB/ezr32lg
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32LG/Source/IAR/: startup_ezr32lg.s
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32LG/Source/: system_ezr32lg.c
  group MCU/EFM32LIB/ezr32wg
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32WG/Source/IAR/: startup_ezr32wg.s
    ../../../src/hal/mcu/EFM32LIB/Device/EZR32WG/Source/: system_ezr32wg.c
